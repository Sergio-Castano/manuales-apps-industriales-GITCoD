Commit message: Reemplazo paquete quanser_digital_twin por versión correcta

File: Fallos/quanser_digital_twin/urdf/motor.urdf (robot description, URDF)
Before this commit: robot motor_robot, 2 links, 1 joints
Links:
- link base_link: mass None -> 0.001
- link motor_link: mass 0.1 -> 0.2
